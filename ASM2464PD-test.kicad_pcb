# Repository a-little-wifi/ASM2464PD-test

File README.md:

# ASM2464PD-test
I wanted to know more about the new Asmedia USB4 chips because I want to make USB-C PCIe stuff.

The ASM2464PD is meant for USB4 (or Thunderbolt 3 and USB3.x too, afaik) to NVMe SSD enclosures, and the ASM2464PDX is meant for USB4/TB to general PCIe devices such as GPUs.  
I've read that the PD one also works for general PCIe devices but it's not officially supported. An AX210 wifi card worked on an ASM2464PD (non-X) enclosure for me, haven't tried GPUs yet.

So anyway I found some sussy data online and made a kicad version of the ASM2464PD pcb footprint and schematic symbol, it's a start to figuring out how to DIY something with these chips. I've got datasheets and reference schematics now so I'm slowly working on making a complete functional replica.  

Current PCB layout is only for fun, differential pairs are not impedance matched yet and there's probably various other issues lol. 

Random Chinese forum link with datasheet screenshots + bits of a reference schematic: https://blog.csdn.net/weixin_54493972/article/details/127628081

Footprint/symbol reference: https://jlcpcb.com/partdetail/Asmedia-ASM2464PD/C7509569

Detailed images of a board: https://www.reddit.com/r/UsbCHardware/comments/17tjmh4/diy_ultra_compact_usb4thunderbolt_4_ssd_enclosure/

Datasheets and reference schematics: https://files.slop.gay/pub/docs/Asmedia/ASM2464PD-X/

## KiCad design ASM2464PD-test.kicad_pcb

Parts:
C1: 10p; C_0402_1005Metric
C2, C3, C4, C5, C6, C7, C8, C9: 0.33u; C_0201_0603Metric
C10, C21: 1u; C_0402_1005Metric
C11: 220p; C_0402_1005Metric; not fitted
C12, C13, C14, C15, C16, C17, C18, C19: 0.22u; C_0402_1005Metric
C20: 0.1u; C_0402_1005Metric
D1, D2, D3, D4, D5, D6, D7, D8: D_0201_0603Metric; not fitted
D9, D10, D11, D12, D13, D14, D15, D16: LED_0603_1608Metric
J1: USB_C_Receptacle; USB_C_Receptacle_Amphenol_12401610E4-2A
J2: SPIheader; PinHeader_2x04_P2.54mm_Vertical
J3: Bus_PCI_Express_x4; PCIe_x4_tht_open
J4: chip-annoyers; PinHeader_2x02_P2.54mm_Vertical
J5: UART; PinHeader_1x04_P2.54mm_Vertical
J6: I2C; PinHeader_1x04_P2.54mm_Vertical
J7, J8, J9, J10: Conn_01x06; PinHeader_1x06_P1.27mm_Vertical
R1, R2, R20, R26, R29, R39, R41, R42, R43: 1k; R_0402_1005Metric
R3, R4, R5, R6, R7, R8, R25, R30, R31: 0Ω; R_0402_1005Metric
R9, R27, R28, R35, R38: 4.7k; R_0402_1005Metric
R10, R21, R22: 10k; R_0402_1005Metric
R11, R12, R13, R14, R15, R16, R17, R18: 220k; R_0201_0603Metric
R23: 10k; R_0402_1005Metric; not fitted
R24: 1k; R_0402_1005Metric; not fitted
R32: 12.1k; R_0402_1005Metric
R33: 100k; R_0402_1005Metric
R34, R36, R37: 4.7k; R_0402_1005Metric; not fitted
U1: ASM2464PD
U2: SPI_SOIC-8; SOIC-8_5.3x5.3mm_P1.27mm
U3: SPI_DFN-8; DFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.5mm
Y1: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V_LDO: C20.1, D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), J2.2, J5.1, J6.1, R21.1, R22.1, R23.1, R27.2, R28.2, R33.2, R34.2, R35.2, U2.8 (VCC), U3.8 (VCC); also elsewhere on the board
+3.3V_SSD: J3.A9 (+3.3V), J3.A10 (+3.3V), J3.B8 (+3.3V), J3.B10 (3.3Vaux)
+5V_VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R9.1
/Main/CC1_C: J1.A5 (CC1), R3.1
/Main/CC2_C: J1.B5 (CC2), R4.1
/Main/PCIe_TX0_C+: C12.2, J3.B14 (PETp0)
/Main/PCIe_TX0_C-: C13.2, J3.B15 (PETn0)
/Main/PCIe_TX1_C+: C14.2, J3.B19 (PETp1)
/Main/PCIe_TX1_C-: C15.2, J3.B20 (PETn1)
/Main/PCIe_TX2_C+: C16.2, J3.B23 (PETp2)
/Main/PCIe_TX2_C-: C17.2, J3.B24 (PETn2)
/Main/PCIe_TX3_C+: C18.2, J3.B27 (PETp3)
/Main/PCIe_TX3_C-: C19.2, J3.B28 (PETn3)
/Main/SBU1_C: J1.A8 (SBU1), R7.1
/Main/SBU2_C: J1.B8 (SBU2), R8.1
/Main/URX0_C+: C3.1, D3.1 (A1), J1.B11 (RX1+), R13.1
/Main/URX0_C-: C2.1, D4.1 (A1), J1.B10 (RX1-), R14.1
/Main/URX1_C+: C7.1, D7.1 (A1), J1.A11 (RX2+), R17.1
/Main/URX1_C-: C6.1, D8.1 (A1), J1.A10 (RX2-), R18.1
/Main/USB2_C_D+: J1.A6 (D+), J1.B6 (D+), R6.1
/Main/USB2_C_D-: J1.A7 (D-), J1.B7 (D-), R5.1
/Main/UTX0_C+: C5.1, D1.1 (A1), J1.A2 (TX1+), R11.1
/Main/UTX0_C-: C4.1, D2.1 (A1), J1.A3 (TX1-), R12.1
/Main/UTX1_C+: C9.1, D5.1 (A1), J1.B2 (TX2+), R15.1
/Main/UTX1_C-: C8.1, D6.1 (A1), J1.B3 (TX2-), R16.1
ActLED1: R1.1, U1.D1 (NVMeACTLED1/GPIO0)
ActLED2: R2.1, U1.A1 (NVMeACTLED2/GPIO3)
ActLED3: R20.1, U1.A16 (NVMeACTLED3/GPIO25)
ActLED4: R29.1, U1.A17 (NVMeACTLED4/GPIO26)
CC1: R3.2, U1.AA6 (CC1)
CC2: R4.2, U1.Y6 (CC2)
CLKREQ0#: J7.5, R21.2, R30.1, U1.A19 (CLKREQ0#/GPIO8)
CLKREQ1#: J8.5, U1.A20 (CLKREQ1#/GPIO14)
CLKREQ2#: J9.5, U1.A14 (CLKREQ2#/GPIO23)
CLKREQ3#: J10.5, U1.A15 (CLKREQ3#/GPIO24)
Card_SMBCLK: J3.B5 (SMCLK), J7.1
Card_SMBDAT: J3.B6 (SMDAT), J7.2
GND: C10.2, C11.2, C20.2, C21.1, D1.2 (A2), D2.2 (A2), D3.2 (A2), D4.2 (A2), D5.2 (A2), D6.2 (A2), D7.2 (A2), D8.2 (A2), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.7, J3.A1 (~PRSNT1), J3.A4 (GND), J3.A12 (GND), J3.A15 (GND), J3.A18 (GND), J3.A20 (GND), J3.A23 (GND), J3.A24 (GND), J3.A27 (GND), J3.A28 (GND), J3.A31 (GND), J3.B4 (GND), J3.B7 (GND), J3.B13 (GND), J3.B16 (GND), J3.B18 (GND), J3.B21 (GND), J3.B22 (GND), J3.B25 (GND), J3.B26 (GND), J3.B29 (GND), J3.B32 (GND), J4.3, J4.4, J5.2, J6.2, J7.3, J8.3, J9.3, J10.3, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R24.2, R26.1, R32.2, R36.1, R37.1, R38.1, U2.4 (GND), U3.4 (GND), Y1.2, Y1.4; also elsewhere on the board
GPIO1: U1.C1 (I2C_INT/GPIO1)
GPIO2: U1.B1 (PRSNT#/GPIO2)
GPIO19: J8.6, U1.A10 (PRSNT1#/GPIO19)
GPIO20: U1.A11 (HDDPC1/GPIO20)
GPIO21: J9.6, U1.A12 (PRSNT2#/GPIO21)
GPIO27: J10.6, U1.A18 (PRSNT3#/GPIO27)
HDDPC: R25.1, U1.C21 (HDDPC)
HDD_PC_EN: R25.2, R26.2
I2C_CLK: J6.3, U1.E1 (I2C_CLK_P)
I2C_DATA: J6.4, U1.F1 (I2C_DATA_P)
unnamed: D9.1 (K), R1.2
unnamed: D10.1 (K), R2.2
unnamed: D11.1 (K), R20.2
unnamed: D12.1 (K), R29.2
unnamed: D13.1 (K), R39.2
unnamed: D14.1 (K), R41.2
unnamed: D15.1 (K), R42.2
unnamed: D16.1 (K), R43.2
unnamed: J3.A2 (+12V), J3.A3 (+12V), J3.B1 (+12V), J3.B2 (+12V), J3.B3 (+12V)
unnamed: J3.B17 (~PRSNT2), J3.B31 (~PRSNT2), R30.2
unnamed: J3.B11 (~WAKE), R31.2
P1_LED: R39.1, U1.A6 (P1_LED/GPIO15)
P2_LED: R41.1, U1.A7 (P2_LED/GPIO16)
P3_LED: R42.1, U1.A8 (P3_LED/GPIO17)
P4_LED: R43.1, U1.A9 (P4_LED/GPIO18)
PCIe_RX0+: J3.A16 (PERp0), U1.N21 (PRXP0)
PCIe_RX0-: J3.A17 (PERn0), U1.N20 (PRXN0)
PCIe_RX1+: J3.A21 (PERp1), U1.W21 (PRXP1)
PCIe_RX1-: J3.A22 (PERn1), U1.W20 (PRXN1)
PCIe_RX2+: J3.A25 (PERp2), U1.Y19 (PRXP2)
PCIe_RX2-: J3.A26 (PERn2), U1.AA19 (PRXN2)
PCIe_RX3+: J3.A29 (PERp3), U1.AA13 (PRXP3)
PCIe_RX3-: J3.A30 (PERn3), U1.Y13 (PRXN3)
PCIe_TX0+: C12.1, U1.R20 (PTXP0)
PCIe_TX0-: C13.1, U1.R21 (PTXN0)
PCIe_TX1+: C14.1, U1.U20 (PTXP1)
PCIe_TX1-: C15.1, U1.U21 (PTXN1)
PCIe_TX2+: C16.1, U1.Y17 (PTXP2)
PCIe_TX2-: C17.1, U1.AA17 (PTXN2)
PCIe_TX3+: C18.1, U1.Y15 (PTXP3)
PCIe_TX3-: C19.1, U1.AA15 (PTXN3)
PERST0#: C11.1, J3.A11 (~PERST), J7.4, R23.2, R24.1, U1.G21 (PERST0#)
PERST1#: J8.4, U1.F21 (NC/PERST1#)
PERST2#: J9.4, U1.E21 (NC/PERST2#)
PERST3#: J10.4, U1.D21 (NC/PERST3#)
PE_WAKE#: J7.6, R22.2, R31.1, U1.A13 (PE_WAKE#/GPIO22)
REFCLK1+: J8.1, U1.AA11 (NC/REFCLKP1)
REFCLK1-: J8.2, U1.Y11 (NC/REFCLKN1)
REFCLK2+: J9.1, U1.AA10 (NC/REFCLKP2)
REFCLK2-: J9.2, U1.Y10 (NC/REFCLKN2)
REFCLK3+: J10.1, U1.AA7 (NC/REFCLKP3)
REFCLK3-: J10.2, U1.Y7 (NC/REFCLKN3)
REFCLK+: J3.A13 (REFCLK+), U1.AA8 (REFCLKP0)
REFCLK-: J3.A14 (REFCLK-), U1.Y8 (REFCLKN0)
RST#: C21.2, J4.1, R33.1, U1.H1 (RST#)
SBU1: R7.2, U1.K1 (SBU1)
SBU2: R8.2, U1.J1 (SBU2)
SPI_CLK: J2.6, U1.A5 (GPIO6/SPI_CLK), U2.6 (SCK), U3.6 (SCK)
SPI_CS#: J2.1, U1.A2 (GPIO4/SPI_CS#), U2.1 (~CS), U3.1 (~CS)
SPI_DI: J2.3, U1.A4 (GPIO7/SPI_DI), U2.2 (MISO), U3.2 (MISO)
SPI_DO: J2.8, R34.1, R37.2, U1.A3 (GPIO5/SPI_DO), U2.5 (MOSI), U3.5 (MOSI)
SPI_HOLD#: J2.4, J4.2, R27.1, U2.7 (~HOLD), U3.7 (~HOLD)
SPI_WP#: J2.5, R28.1, U2.3 (~WP), U3.3 (~WP)
TEST_EN: R38.2, U1.H21 (TEST_EN)
UART_RX: J5.4, U1.A21 (PRSNT0#/UART_RX)
UART_TX: J5.3, R35.1, R36.2, U1.B21 (MEMREPAIR/UART_TX)
UREXT: R32.1, U1.AA3 (REXT)
URX0+: C3.2, U1.P1 (URXP0)
URX0-: C2.2, U1.P2 (URXN0)
URX1+: C7.2, U1.Y2 (URXP1)
URX1-: C6.2, U1.Y1 (URXN1)
USB2_D+: R6.2, U1.M1 (UDP)
USB2_D-: R5.2, U1.M2 (UDM)
UTX0+: C5.2, U1.T1 (UTXP0)
UTX0-: C4.2, U1.T2 (UTXN0)
UTX1+: C9.2, U1.V2 (UTXP1)
UTX1-: C8.2, U1.V1 (UTXN1)
VBUS: C10.1, R9.2, R10.1, U1.G1 (VBUS)
XI: C1.2, U1.AA4 (XI), Y1.3
XO: C1.1, U1.Y4 (XO), Y1.1

Notes on the sheet:
0201 for USB4
Mystery LED 2
H/W Strapping
Ultra-Mystery LED 2
TODO: [x] UART header 3V3 GND TX RX [x] I2C header 3V3 GND CLK DATA [x] SPI header with SPI flash pinout [x] Jumper/button for SPI /HOLD [x] Jumper/button for ASM RST# [ ] CC testpoints [ ] add a bunch of decoupling capacitors [ ] make sure clkreq works on more-than-x4 cards too (prsnt)
Device LED
R/W LED
Mystery LED
Ultra-Mystery LED
Ultra-Mystery LED 3
SPI ROM
Ultra-Mystery LED 4

Parts:
R40: 0Ω; R_0402_1005Metric
U1: ASM2464PD

Connections:
+3.3VA: R40.2, U1.H5 (VCCA33)
+3.3V_LDO: R40.1, U1.D6 (VCCH), U1.D8 (VCCH), U1.D9 (VCCH), U1.D13 (VCCH), U1.E6 (VCCH), U1.E8 (VCCH), U1.E9 (VCCH), U1.E13 (VCCH), U1.F6 (VCCH), U1.F13 (VCCH), U1.H6 (VCCH); also elsewhere on the board
GND: U1.AA1 (GNDA), U1.AA2 (GNDA), U1.AA5 (GNDA), U1.AA9 (GNDA), U1.AA12 (GNDA), U1.AA14 (GNDA), U1.AA16 (GNDA), U1.AA18 (GNDA), U1.AA20 (GNDA), U1.AA21 (GNDA), U1.D4 (GND), U1.D5 (GND), U1.D11 (GND), U1.D17 (GND), U1.D18 (GND), U1.E4 (GND), U1.E5 (GND), U1.E17 (GND), U1.E18 (GND), U1.F4 (GND), U1.F5 (GND), U1.F8 (GND), U1.F17 (GND), U1.F18 (GND), U1.H4 (GND), U1.H8 (GND), U1.H17 (GND), U1.H18 (GND), U1.J4 (GND), U1.J5 (GND), U1.J6 (GND), U1.J11 (GND), U1.K2 (GND), U1.L1 (GNDA), U1.L2 (GNDA), U1.L4 (GNDA), U1.L5 (GNDA), U1.L9 (GND), U1.L13 (GND), U1.M20 (GNDA), U1.M21 (GNDA), U1.N1 (GNDA), U1.N2 (GNDA), U1.N4 (GNDA), U1.N5 (GNDA), U1.N9 (GND), U1.N11 (GND), U1.N13 (GND), U1.N17 (GNDA), U1.N18 (GNDA), U1.P4 (GNDA), U1.P5 (GNDA), U1.P9 (GND), U1.P11 (GND), U1.P17 (GNDA), U1.P18 (GNDA), U1.P20 (GNDA), U1.P21 (GNDA), U1.R1 (GNDA), U1.R2 (GNDA), U1.T4 (GNDA), U1.T5 (GNDA), U1.T17 (GNDA), U1.T18 (GNDA), U1.T20 (GNDA), U1.T21 (GNDA), U1.U1 (GNDA), U1.U2 (GNDA), U1.U4 (GNDA), U1.U5 (GNDA), U1.U17 (GNDA), U1.U18 (GNDA), U1.V4 (GNDA), U1.V5 (GNDA), U1.V6 (GNDA), U1.V8 (GNDA), U1.V9 (GNDA), U1.V11 (GNDA), U1.V13 (GNDA), U1.V14 (GNDA)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; also elsewhere on the board
VCCL: U1.L6 (VCCL), U1.L16 (VCCL), U1.L17 (VCCL), U1.L18 (VCCL), U1.L20 (VCCL), U1.L21 (VCCL), U1.N6 (VCCL), U1.N16 (VCCL), U1.P6 (VCCL), U1.P16 (VCCL), U1.T6 (VCCL), U1.T16 (VCCL), U1.U6 (VCCL), U1.U11 (VCCL), U1.U13 (VCCL), U1.U14 (VCCL), U1.U16 (VCCL)
VDD: U1.D14 (VDD), U1.D16 (VDD), U1.E11 (VDD), U1.E14 (VDD), U1.E16 (VDD), U1.F9 (VDD), U1.F11 (VDD), U1.F14 (VDD), U1.F16 (VDD), U1.H9 (VDD), U1.H11 (VDD), U1.H13 (VDD), U1.H14 (VDD), U1.H16 (VDD), U1.J8 (VDD), U1.J9 (VDD), U1.J13 (VDD), U1.J14 (VDD), U1.J16 (VDD), U1.J17 (VDD), U1.J18 (VDD), U1.J20 (VDD), U1.J21 (VDD), U1.K20 (VDD), U1.K21 (VDD), U1.L8 (VDD), U1.L11 (VDD), U1.L14 (VDD), U1.N8 (VDD), U1.N14 (VDD), U1.P8 (VDD), U1.P13 (VDD), U1.P14 (VDD), U1.T8 (VDD), U1.T9 (VDD), U1.T11 (VDD), U1.T13 (VDD), U1.T14 (VDD), U1.U8 (VDD), U1.U9 (VDD)

Notes on the sheet:
TODO: separate ssd and asm 3.3V rails
insert 5V to 1.13V (? maybe as low as 0.95?) switching regulator here 3A (VDD/core)
insert 5V to 1.9V switching regulator here 2A (VCCL)
insert 5V to 3.3V switching regulator here 4A (SSD)
insert 5V to 3.3V linear regulator here (1117 33) (VCCH/SYS)
random retail asm2464pd board according to my cheap uncalibrated multimeter: VDD: 1.120V VCCL: 1.940V

Board: 4 copper layers, 81.8 x 19.0 mm, 93 parts (0 on the bottom side), 118 nets.

## Commit log

2024-03-12 Added project files
2024-03-12 Wrote in readme
2024-03-12 Added lock files to gitignore and removed them
2024-03-12 Connected the 2 grounds
    what's the difference anyway
2024-03-12 Better readme
2024-03-12 Added some keywords to readme
2024-03-12 Added ports and definitely didn't clone reddit board lol
2024-03-14 Tried adding power fills under the chip
2024-03-14 Slightly moved a diffpair
2024-03-14 Updated PCB pics
    don't mind the cat
2024-03-14 forgor some power pins
2024-03-16 slightly moved a pair lol
2024-04-05 Labeled power rails, upgraded to KiCad 8
2024-04-14 Updated symbol to match reference schematic
2024-04-14 Updated schematic and rerouted some stuff
2024-04-14 Added SPI flash, probably some more stuff, and made pcb 4-layer
2024-04-14 Added lots of power rail vias under chip
2024-04-15 reran the other 2 USB4 pairs too, placed esd stuff
2024-04-15 Moved SPI flash footprint onto board
2024-04-15 Removed stupid custom schematic drawing sheet that didn't even work lol
2024-04-26 Adjusted ground fill under bga
2024-04-26 Bunch more stuff copied from reference schematic
2024-04-27 changed ground trace width to match footprint pads
2024-04-29 silly
2024-04-29 unsilly
2024-08-06 more schematic work
2024-08-15 Updated power rails
2024-09-15 Updated outdate readme mentioning lack of info
    I already got the datasheets and schematics a while ago but never updated the readme....
2024-10-13 Added todo list
2025-09-22 Changing from M.2 adapter to PCIe x4 adapter
    I don't actually want an ssd enclosure, I want a PCIe-slot-giver for my laptop
2025-09-26 Added link to datasheets and reference schematics to readme + some other changes I forgot what I did lol
    thanks @mothenjoyer69 for hosting them!
2025-09-29 Cleaning up schematic a bit
    Directly copying the reference schematic was stupid lol, what a mess
2025-09-29 power notes
2025-09-30 Added function names to gpio pins
2025-09-30 more pin names, more schematic cleanup, added SPI header
    baby I don't know when I'm supposed to stop (I should go to bed)
2025-09-30 Very bad routing lol
    should probably not try to make it *that* compact
2025-09-30 component arrangement
2025-10-02 A loooot of cool routing and added more connectors
2025-10-02 Horrible nightmare routing
    oh my stars will it do gen 4?
2025-10-02 Connected all the pcie lanes
    this fit together way too well lol, how even
2025-10-02 Updated readme with new pictures
2025-10-02 Made some space for future 12V supply trace
2025-10-03 some notes
2025-10-03 Added ASM2464PD 3D model
    yoinked from here, thanks https://github.com/Leaves232/2230-USB4-SSD-Enclosure-Design
2025-10-06 Adjusted fills under asm2464pd a bit
